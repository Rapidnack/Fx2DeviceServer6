<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>JJY Clock</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cic_gain</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cic_rate</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>37500 &lt;&lt; cic_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_decode</value></param>
<param><key>block_id</key><value>epy_block_1</value></param>
<param><key>function_name</key><value>get_decode</value></param>
<param><key>value</key><value>''</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_time</value></param>
<param><key>block_id</key><value>epy_block_1</value></param>
<param><key>function_name</key><value>get_time</value></param>
<param><key>value</key><value>''</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_fx2_gui_label</key>
<param><key>id</key><value>variable_fx2_gui_label_time</value></param>
<param><key>value</key><value>variable_function_probe_time</value></param>
<param><key>formatter</key><value>'{0}'.format</value></param>
<param><key>label</key><value>TIME</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_decode</value></param>
<param><key>value</key><value>variable_function_probe_decode</value></param>
<param><key>formatter</key><value>'{0}'.format</value></param>
<param><key>label</key><value>DECODE</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_rate / 10</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>address</key><value>'127.0.0.1'</value></param>
<param><key>cic_gain</key><value>cic_gain</value></param>
<param><key>cic_rate</key><value>cic_rate</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import socket

class blk(gr.basic_block):
    """Embedded Python Block example - ADC_SA_SDR"""

    def __init__(self, address='127.0.0.1', port=53006, led=0, frequency=1e3, cic_rate=3, cic_gain=8):
        gr.basic_block.__init__(
            self,
            name='ADC_SA_SDR',
            in_sig=None,
            out_sig=None
        )
        self._address = address
        self._port = port
        self._led = led
        self._frequency = frequency
        self._cic_rate = cic_rate
        self._cic_gain = cic_gain

        try:
            self._connect()
            self._send_led()
            self._send_frequency()
            self._send_cic_rate()
            self._send_cic_gain()
        except:
            pass

    def _connect(self):
        print('connecting to %s:%d' % (self._address, self._port))
        self._client = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
        self._client.connect((self._address, self._port))
        self._stream = self._client.makefile()

    def _send_led(self):
        try:
            self._stream.write('*W32:0x%x 0x%x\n' % (0x0, int(self._led)))
            self._stream.flush()
        except:
            self._connect()
            self._stream.write('*W32:0x%x 0x%x\n' % (0x0, int(self._led)))
            self._stream.flush()

    def _freq_to_ddc(self, clk, freq):
        clkDiv2 = clk / 2.0
        bank = np.floor(freq / clkDiv2)
        lo = freq - clkDiv2 * bank
        if (bank % 2) == 1:
            lo = clkDiv2 - lo
        return lo

    def _freq_to_phase_inc(self, clk, freq):
        phaseInc360 = 0x80000000 * 2.0
        return int(phaseInc360 * (self._freq_to_ddc(clk, freq) / clk))

    def _send_frequency(self):
        clk = 48000000
        phaseInc = self._freq_to_phase_inc(clk, self._frequency)
        clkDiv2 = clk / 2.0
        bank = np.floor(self._frequency / clkDiv2)
        iq_swap = int(bank % 2)
        try:
            self._stream.write('*W32:0x%x 0x%x\n' % (0x10, phaseInc))
            self._stream.write('*W32:0x%x %d\n' % (0x20, iq_swap))
            self._stream.flush()
        except:
            self._connect()
            self._stream.write('*W32:0x%x 0x%x\n' % (0x10, phaseInc))
            self._stream.write('*W32:0x%x %d\n' % (0x20, iq_swap))
            self._stream.flush()

    def _send_cic_rate(self):
        try:
            self._stream.write('*W32:0x%x %d\n' % (0x30, int(self._cic_rate)))
            self._stream.flush()
        except:
            self._connect()
            self._stream.write('*W32:0x%x %d\n' % (0x30, int(self._cic_rate)))
            self._stream.flush()

    def _send_cic_gain(self):
        try:
            self._stream.write('*W32:0x%x %d\n' % (0x40, int(self._cic_gain)))
            self._stream.flush()
        except:
            self._connect()
            self._stream.write('*W32:0x%x %d\n' % (0x40, int(self._cic_gain)))
            self._stream.flush()

    @property
    def led(self):
        return self._led

    @led.setter
    def led(self, led):
        self._led = led
        self._send_led()

    @property
    def frequency(self):
        return self._frequency

    @frequency.setter
    def frequency(self, frequency):
        self._frequency = frequency
        self._send_frequency()

    @property
    def cic_rate(self):
        return self._cic_rate

    @cic_rate.setter
    def cic_rate(self, cic_rate):
        self._cic_rate = cic_rate
        self._send_cic_rate()

    @property
    def cic_gain(self):
        return self._cic_gain

    @cic_gain.setter
    def cic_gain(self, cic_gain):
        self._cic_gain = cic_gain
        self._send_cic_gain()
</value></param>
<param><key>frequency</key><value>30e3</value></param>
<param><key>led</key><value>0</value></param>
<param><key>port</key><value>53006</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import sys

class blk(gr.sync_block):
    """Embedded Python Block example - JJY Decoder"""

    def __init__(self, sample_rate=37500):
        gr.sync_block.__init__(
            self,
            name='JJY Decoder',
            in_sig=[np.float32],
            out_sig=None
        )
        self.sample_rate = int(sample_rate)

        self._level_count = 0
        self._min = sys.float_info.max
        self._max = 0
        self._minimum = None
        self._threshold = None
        self._maximum = None

        self._count = 0
        self._last_value = None
        self._last_rise = None
        self._rise_count = None
        self._next_rise_count = None

        self._minute_sum = 0
        self._minute_min = sys.float_info.max
        self._minute_max = 0
        self._minute_count = None
        self._bits = []
        self._decode_hhmm = '--:--'
        self._hhmm = '--:--'
        self._next_hhmm = '--:--'

    def _get_hhmm(self):
        if len(self._bits) &lt; 38 or self._bits[0] != 'M':
            return '--:--'
        if self._bits[1:9].count('X') &gt; 0 or self._bits[37] == 'X':
            return '--:--'
        if self._bits[1:9].count('P') &gt; 0 or self._bits[37] == 'P':
            return '--:--'
        if self._bits[12:19].count('X') &gt; 0 or self._bits[36] == 'X':
            return '--:--'
        if self._bits[12:19].count('P') &gt; 0 or self._bits[36] == 'P':
            return '--:--'
        p = 0; m = 0
        if self._bits[1] == '1': p += 1; m += 40
        if self._bits[2] == '1': p += 1; m += 20
        if self._bits[3] == '1': p += 1; m += 10
        if self._bits[5] == '1': p += 1; m += 8
        if self._bits[6] == '1': p += 1; m += 4
        if self._bits[7] == '1': p += 1; m += 2
        if self._bits[8] == '1': p += 1; m += 1
        if self._bits[37] == '1': p += 1
        if (p % 2) != 0 or m &gt; 59:
            return '--:--'
        p = 0; h = 0
        if self._bits[12] == '1': p += 1; h += 20
        if self._bits[13] == '1': p += 1; h += 10
        if self._bits[15] == '1': p += 1; h += 8
        if self._bits[16] == '1': p += 1; h += 4
        if self._bits[17] == '1': p += 1; h += 2
        if self._bits[18] == '1': p += 1; h += 1
        if self._bits[36] == '1': p += 1
        if (p % 2) != 0 or h &gt; 23:
            return '--:--'
        s = '%02d:%02d' % (h, m)
        print '(%s)' % s,
        return s

    def _get_next_hhmm(self):
        if self._hhmm.count('-') &gt; 0:
            return '--:--'
        h = int(self._hhmm[:2])
        m = int(self._hhmm[3:])
        if m &lt; 59:
            m1 = m + 1
            h1 = h
        else:
            m1 = 0
            if h &lt; 23:
                h1 = h + 1
            else:
                h1 = 0
        return '%02d:%02d' % (h1, m1)

    def _get_second(self):
        if self._minute_count == None:
            return -1
        else:
            return int(round(float(self._count - self._minute_count) / self.sample_rate))

    def get_decode(self):
        return self._decode_hhmm

    def get_time(self):
        if self._hhmm == '--:--':
            return '--:--:--'
        second = '--'
        sec = self._get_second()
        if sec &gt;= 0:
            if sec &gt;= 60:
                self._hhmm = self._next_hhmm
                sec -= 60
            second = '%02d' % sec
        return '%s:%s' % (self._hhmm, second)

    def work(self, input_items, output_items):

        #
        # Update self._minimum, self._threshold and self._maximum every 4 seconds
        #
        self._min = min(self._min, np.min(input_items[0]))
        self._max = max(self._max, np.max(input_items[0]))
        self._level_count += len(input_items[0])
        if self._level_count &gt;= self.sample_rate * 4:
            self._minimum = self._min
            self._threshold = (self._min + self._max) / 2
            self._maximum = self._max
            #print self._minimum, self._threshold, self._maximum
            self._level_count = 0
            self._min = sys.float_info.max
            self._max = 0
        if self._threshold == None:
            return len(input_items[0])

        #
        # Find the rising position at 1 second intervals
        #
        if self._threshold != None:
            if self._last_value == None:
                self._last_value = 1 if input_items[0][0] &gt; self._threshold else 0

            p = 0
            while p &lt; len(input_items[0]):
                if self._last_value == 0:
                    result = np.where(input_items[0][p:] &gt; self._threshold * 1.1)
                    if len(result[0]) == 0:
                        break
                    p += result[0][0]
                    rise = self._count + p
                    if self._last_rise != None:
                        period = float(rise - self._last_rise) / self.sample_rate
                        #print period
                        if 0.9 &lt;= period and period &lt;= 1.1:
                            if self._rise_count == None:
                                self._rise_count = rise
                            else:
                                if rise &lt; self._rise_count + self.sample_rate / 2:
                                    self._rise_count = rise
                                    #print '&gt;',
                                else:
                                    self._rise_count = rise - self.sample_rate
                                    #print '&lt;',
                    self._last_rise = rise
                    self._last_value = 1
                else:
                    result = np.where(input_items[0][p:] &lt; self._threshold * 0.9)
                    if len(result[0]) == 0:
                        break
                    p += result[0][0]
                    self._last_value = 0

        #
        # Distinguish the code from the total of the levels for 1 second
        #
        if self._rise_count != None:
            p1 = self._rise_count - self._count
            p2 = self._rise_count + self.sample_rate - self._count

            # p1  [0]  [-1]  p2
            if p1 &lt;= 0 and len(input_items[0]) &lt;= p2:
                self._minute_sum += np.sum(input_items[0][:])
                self._minute_min = min(self._minute_min, np.min(input_items[0][:]))
                self._minute_max = max(self._minute_max, np.max(input_items[0][:]))
            # [0]  p1  [-1]  p2
            elif 0 &lt; p1 and p1 &lt; len(input_items[0]) and len(input_items[0]) &lt;= p2:
                self._minute_sum += np.sum(input_items[0][p1:])
                self._minute_min = min(self._minute_min, np.min(input_items[0][p1:]))
                self._minute_max = max(self._minute_max, np.max(input_items[0][p1:]))
            # p1  [0]  p2  [-1]
            elif p1 &lt;= 0 and 0 &lt; p2 and p2 &lt; len(input_items[0]):
                self._minute_sum += np.sum(input_items[0][:p2])
                self._minute_min = min(self._minute_min, np.min(input_items[0][:p2]))
                self._minute_max = max(self._minute_max, np.max(input_items[0][:p2]))

            if 0 &lt;= p2 and p2 &lt; len(input_items[0]):
                bit = '-'
                if (self._hhmm[-2:] in ('15', '45')) and 40 &lt;= len(self._bits) and len(self._bits) &lt;= 55:
                    pass
                else:
                    average = self._minute_sum / self.sample_rate
                    ratio = (average - self._minute_min) / (self._minute_max - self._minute_min)
                    bit = 'P'
                    if ratio &gt; 0.6:
                       bit = '0'
                    elif ratio &gt; 0.35:
                       bit = '1'
                if (len(self._bits) &gt; 0 and self._bits[-1] == 'P' and bit == 'P') or len(self._bits) == 60:
                    self._hhmm = self._next_hhmm
                    self._minute_count = self._rise_count
                    self._bits = []
                    bit = 'M'
                if bit == 'M':
                    print
                print bit,
                self._bits.append(bit)
                if len(self._bits) == 38:
                    self._decode_hhmm = self._get_hhmm()
                    if self._decode_hhmm != '--:--':
                        self._hhmm = self._decode_hhmm
                    next_hhmm = self._get_next_hhmm()
                    if next_hhmm != '--:--':
                        self._next_hhmm = next_hhmm

                self._rise_count = self._count + p2
                self._minute_sum = 0
                self._minute_min = sys.float_info.max
                self._minute_max = 0

        self._count += len(input_items[0])

        return len(input_items[0])
</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fx2_iq_udp_source</key>
<param><key>id</key><value>fx2_iq_udp_source_0</value></param>
<param><key>ipaddr</key><value>'0.0.0.0'</value></param>
<param><key>port</key><value>52006</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>samp_rate * 4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fx2_iq_udp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fx2_iq_udp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
